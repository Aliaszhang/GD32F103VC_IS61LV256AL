# Keil uVision project gd32f103vc_sram.uvprojx, settings and files
target gd32f103_sram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F103VK GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f103vc_sram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_XD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\CMSIS\GD\GD32F10x\Include;..\INCLUDE;..\LIB\Include;..\SOURCE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT6: RAM 0x60000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../SOURCE/: exmc_sram.c gd32f10x_it.c main.c systick.c
  group CMSIS
    ../CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group LIB
    ../LIB/Source/: gd32f10x_exmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c
  group STARTUP
    ../CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_xd.s
